# Keil uVision project F427-Demo.uvprojx, settings and files
target F427-Demo (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F427VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F427-Demo
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F427_437xx,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS,__FPU_PRESENT=1,__FPU_USED=1,ARM_MATH_CM4,ARM_MATH_MATRIX_CHECK
  c misc: --gnu
  c include: .\source\Applications;.\source\FreeRTOS\include;.\source\Libraries\CMSIS\Include;.\source\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\source\System;.\source\FreeRTOS\portable\RVDS\ARM_CM4F;.\source\FATFS;.\source\Driver\SDIO;.\source\Driver\USB;.\source\letter-shell;.\source\mavlink\include;.\source\mavlink\include\autoquad;.\source\mavlink\include\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Objects\F427-Demo.sct
  group App
    ./source/Applications/: main.c d_imu.c digital.c ext_irq.c mpu6000.c spi.c tick.c util.c ms5611.c hmc5983.c config.c eeprom.c flash.c supervisor.c comm.c filer.c rcc.c serial.c telemetry.c gps.c ublox.c imu.c alt_ukf.c srcdkf.c algebra.c compass.c nav_ukf.c run.c aq_mavlink.c uwb.c
  group CMSIS
    ./source/Applications/: stm32f4xx_it.c system_stm32f4xx.c startup_stm32f427_437xx.s
    ./source/Libraries/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group FreeRTOS
    ./source/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./source/FreeRTOS/portable/MemMang/: heap_4.c
    ./source/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group STM32F4xx_StdPeriph_Driver
    ./source/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group System
    ./source/System/: sys.c usart.c
  group FATFS
    ./source/FATFS/: ff.c
  group SDIO
    ./source/Driver/SDIO/: sdio.c
  group USB
    ./source/Driver/USB/: usb.c usb_bsp.c usb_core.c usb_dcd.c usb_dcd_int.c usb_hcd.c usb_hcd_int.c usbd_cdc_msc_core.c usbd_core.c usbd_desc.c usbd_ioreq.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c usbd_req.c usbd_storage_msd.c
  group Shell
    ./source/letter-shell/: shell.c shell_ext.c
